# Autodesk Inventor assembly: 520144_AC-SCM7U-BT
## iProperties
Created: 2011-05
Part Number: 520144_AC-SCM7U-BT
Document SubType Name: Assembly
Designer: seisen
Author: seisen
